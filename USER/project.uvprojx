# Keil uVision project project.uvprojx, settings and files
target Target (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\DECODE;..\LAUNCH;..\RECEIVE;..\MODULATE;..\DRIVER;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\REMOTE;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c
  group DECODE
    ../DECODE/: README.txt
  group LAUNCH
    ../LAUNCH/: README.txt
  group RECEIVE
    ../RECEIVE/: README.txt receive.c
  group MODULATE
    ../MODULATE/: README.txt modulate.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/LCD/: ILI93xx.c
  group DRIVER
    ../DRIVER/: startup_stm32f10x_hd.s
